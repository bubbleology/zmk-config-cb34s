## config/boards/shields/ut22/Kconfig.defconfig
```kconfig
# SPDX-License-Identifier: MIT

if SHIELD_CB34S

config ZMK_KEYBOARD_NAME
    default "cb34s"

endif
```
